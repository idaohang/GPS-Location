# IAR project LED.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207C8 STM8S207C8
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\My_Lib\delay; ..\User; ..\app; ..\System; ..\My_Lib\LED; ..\My_Lib\SPI; ..\My_Lib\USART; ..\My_Lib\AD; ..\My_Lib\EXIT; ..\My_Lib\PWM; ..\My_Lib\Time
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.hex
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s207c8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../app/: DS1302.c GPS.c GPS.h GSM.c GSM.h key.c key.h OLED.c
  group My_Lib
    ../My_Lib/delay/: delay.c
    ../My_Lib/LED/: led.c
    ../My_Lib/Time/: Time.c
    ../My_Lib/USART/: USART.c
  group User
    ../User/: main.c Sys.c
